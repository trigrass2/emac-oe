SRC_BRANCH="master"
SRC_URI = "git://github.com/MicrochipTech/websocket-buildroot-external-microchip.git;protocol=https;branch=${SRC_BRANCH}"

