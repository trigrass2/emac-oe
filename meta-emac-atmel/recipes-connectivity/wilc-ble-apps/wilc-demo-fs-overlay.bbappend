SRC_BRANCH="master"
SRC_URI = "git://github.com/MicrochipTech/wilcbtapps-buildroot-external-microchip.git;protocol=https;branch=${SRC_BRANCH}"

