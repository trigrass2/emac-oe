PROVIDES += " \
    virtual/egl \
    virtual/libgles1 \
    virtual/libgles2 \
    virtual/libgles3 \
    virtual/libgl \
"


