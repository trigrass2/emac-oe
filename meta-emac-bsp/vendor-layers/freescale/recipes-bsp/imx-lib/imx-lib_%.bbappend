SRC_URI = "git://git.emacinc.com/nxp-sources/imx-lib.git;protocol=http;branch=${SRCBRANCH}"
 
