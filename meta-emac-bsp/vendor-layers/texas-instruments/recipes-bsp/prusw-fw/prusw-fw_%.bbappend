TARGET:som-5728m = "am57xx-pru0-prusw-fw.elf am57xx-pru1-prusw-fw.elf"
COMPATIBLE_MACHINE:append = "|som-5728m"