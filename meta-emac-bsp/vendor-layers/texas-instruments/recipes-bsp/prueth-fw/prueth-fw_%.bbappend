TARGET:som-5728m = "am57xx-pru0-prueth-fw.elf am57xx-pru1-prueth-fw.elf"
COMPATIBLE_MACHINE:append = "|som-5728m"