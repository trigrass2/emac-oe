PROVIDES:append = " nativesdk-${PN} ${PN}-native"
RPROVIDES:${PN}:append = " nativesdk-${PN} ${PN}-native"