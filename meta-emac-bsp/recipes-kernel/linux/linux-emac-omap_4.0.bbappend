FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

COMPATIBLE_MACHINE = "som3517|som3354"

SRC_URI += " \
		file://defconfig \
	"
