FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

COMPATIBLE_MACHINE = "somimx6"

SRC_URI += " \
		file://defconfig \
	"
