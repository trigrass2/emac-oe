FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

COMPATIBLE_MACHINE = "som9g45"

SRC_URI += " \
		file://defconfig \
	"
