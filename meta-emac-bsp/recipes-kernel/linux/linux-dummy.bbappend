
COMPATIBLE_MACHINE = "emac-arm|emac-x86"
