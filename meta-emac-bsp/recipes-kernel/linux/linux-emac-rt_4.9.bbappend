FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

COMPATIBLE_MACHINE = "somimx6-rt|"

SRC_URI += " \
		file://defconfig \
	"
