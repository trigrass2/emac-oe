PACKAGECONFIG:corei7-64-intel-common = " \
    wayland-client \
    wayland-server \
    wayland-egl \
"


