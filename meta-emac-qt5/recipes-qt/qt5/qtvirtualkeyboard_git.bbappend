PACKAGECONFIG:append = " hunspell "
DEPENDS:append = " hunspell-dicts "
