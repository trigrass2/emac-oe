PACKAGECONFIG:append:atom-sbc = " \
    proprietary-codecs \
    libvpx \
    ffmpeg \
    opus \
    libwebp \
"
