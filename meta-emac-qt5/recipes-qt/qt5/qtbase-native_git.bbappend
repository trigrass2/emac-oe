PACKAGECONFIG:append = " openssl gui imageformats "
