## should only be for qt builds
## at the moment we dont really have a env that is good to test if there is a qt5 build going on. 

BBCLASSEXTEND:somimxq-ha = "native nativesdk"


