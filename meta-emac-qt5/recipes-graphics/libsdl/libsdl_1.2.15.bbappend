DEPENDS:remove = "virtual/libgl libglu"
