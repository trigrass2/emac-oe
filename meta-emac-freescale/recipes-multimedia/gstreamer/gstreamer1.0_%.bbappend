## Redirect source to EMAC mirror of upstream repository
GST1.0_SRC = "git://git.emacinc.com/nxp-sources/gstreamer.git;protocol=http"
