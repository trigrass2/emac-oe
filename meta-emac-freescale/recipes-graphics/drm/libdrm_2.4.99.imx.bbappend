IMX_LIBDRM_SRC = "git://git.emacinc.com/nxp-sources/libdrm-imx.git;protocol=http;nobranch=1" 
