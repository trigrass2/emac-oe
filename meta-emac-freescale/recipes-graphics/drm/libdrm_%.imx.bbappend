IMX_LIBDRM_SRC = "http://git.emacinc.com/nxp-sources/libdrm-imx.git;protocol=http;nobranch=1" 
