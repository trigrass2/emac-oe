
PACKAGECONFIG_append_somimx6q-ha = "viv-fb jpeg" 
PACKAGECONFIG_remove_somimx6q-ha = "opengl egl"
PACKAGECONFIG_GL_somimx6q-ha = "gles2 gl"

# DEPENDS_somimx6q-ha += "imx-gpu-viv"
