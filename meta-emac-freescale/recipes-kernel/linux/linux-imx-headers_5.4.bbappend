SRCBRANCH = "upstream/imx_5.4.24_2.1.0"

SRC_URI = "git://git.emacinc.com/nxp-sources/linux-imx.git;protocol=http;branch=${SRCBRANCH}"
 
