KERNEL_SRC = "git://git.emacinc.com/nxp-sources/linux-imx.git;protocol=http;branch=${SRCBRANCH}" 
