KERNEL_SRC = "http://git.emacinc.com/nxp-sources/linux-imx.git;protocol=http" 
