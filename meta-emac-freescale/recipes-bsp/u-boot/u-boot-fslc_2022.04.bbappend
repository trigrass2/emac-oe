SRCREV = "7d7decc09818f5b7bd6426f4336a2af1f61f7515"
SRCBRANCH = "2022.04+fslc-pmb"
SRC_URI = "git://git.emacinc.com/bootloader/u-boot-fslc.git;branch=${SRCBRANCH};protocol=http"
