SRC_URI = "git://git.emacinc.com/nxp-sources/uboot-imx.git;protocol=http;branch=${SRCBRANCH}"
