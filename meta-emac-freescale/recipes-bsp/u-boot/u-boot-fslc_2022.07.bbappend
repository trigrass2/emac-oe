SRCREV = "54351aa8e31d1f5ffeb2f6e44eb8d1859ff3b083"
SRCBRANCH = "2022.07+fslc-pmb"
SRC_URI = "git://git.emacinc.com/bootloader/u-boot-fslc.git;branch=${SRCBRANCH};protocol=http"
