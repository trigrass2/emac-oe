SRC_URI = "http://git.emacinc.com/nxp-sources/imx-lib.git;protocol=http;branch=${SRCBRANCH}"
 
