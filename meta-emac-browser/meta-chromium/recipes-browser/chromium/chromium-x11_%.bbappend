
PACKAGECONFIG_x86-64_append = " \
    cups \
    kiosk-mode \
    proprietary-codecs \
    use-vaapi \
"
