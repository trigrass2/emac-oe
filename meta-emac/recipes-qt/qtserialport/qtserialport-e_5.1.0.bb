inherit qt4e

require qtserialport.inc

SRCREV = "56ebaecf3a45e0fe54b849bc3ba4f22919ea3de0"
