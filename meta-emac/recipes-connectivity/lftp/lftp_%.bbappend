BBCLASSEXTEND:append = " \
    native \
    nativesdk \
" 
