do_install_append() {
    rm -rf ${D}${sysconfdir}/udev
}
