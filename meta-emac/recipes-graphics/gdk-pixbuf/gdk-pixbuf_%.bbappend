#Add x11 support
PACKAGECONFIG_append = " x11"
