#Enable alsa
PACKAGECONFIG = "alsa"
