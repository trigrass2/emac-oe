FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
		file://rc \
		file://rcS-default \
	"
