
COMPATIBLE_MACHINE = "emac-arm|emac-x86|emac-x86-64"
