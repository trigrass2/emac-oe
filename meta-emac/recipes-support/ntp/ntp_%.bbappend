FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

# in ntp

#/var/lib/ntp/ntp.drift << ntp user
#/var/log/ntpstats/ << mkdir

#/etc/cron.daily/ntp
#/etc/default/ntp
#/etc/default/ntpdate
#/etc/cron.daily/ntp


#in network manager
#/etc/dhcp/dhclient-exit-hooks.d/ntpdate
#/etc/dhcp/dhclient-exit-hooks.d/ntp
#/etc/NetworkManager/dispatcher.d/ntp

