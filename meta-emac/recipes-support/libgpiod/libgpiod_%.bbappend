PACKAGECONFIG:append = " cxx "
