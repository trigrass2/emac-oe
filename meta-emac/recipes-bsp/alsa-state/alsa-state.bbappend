FILESEXTRAPATHS:prepend = "${THISDIR}/${PN}:"
