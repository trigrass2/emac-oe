
PACKAGECONFIG:x86-64:append = " \
    cups \
    kiosk-mode \
    proprietary-codecs \
    use-vaapi \
"
