FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
DEPENDS: = " harden-web-servers"
RDEPENDS: = " harden-web-servers"
