FILESEXTRAPATHS:prepend := "${THISDIR}/ti-sgx-ddk-km:"
TARGET_PRODUCT = "jacinto6evm"
 
