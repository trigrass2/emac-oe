SRCIPK_SRC_DIR = "${S}/${PLATFORM_ARCH}"
