FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-native-state-drm-restrict-udev-enumeration-to-card0-.patch"

