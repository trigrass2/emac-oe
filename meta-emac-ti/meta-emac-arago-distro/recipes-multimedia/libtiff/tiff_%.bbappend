PACKAGECONFIG:remove = "lzma"
