## FIXME make checks for wayland vs fb vs x11
CXXFLAGS  += " -DEGL_API_WAYLAND "
COMPATIBLE_MACHINE = "(ti33x|omap-a15|dra7xx|qemuarm|qemux86-64)"
