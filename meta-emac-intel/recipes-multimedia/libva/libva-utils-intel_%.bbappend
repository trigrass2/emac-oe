SRC_URI_remove = "git://github.com/intel/libva-utils.git;branch=v2.6-branch"
