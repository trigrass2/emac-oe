PACKAGECONFIG += " openssl gui imageformats "
